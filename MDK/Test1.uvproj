# Keil uVision project Test1.uvproj, settings and files
target Test1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Test1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F103x_MD
  c include: ..\STM32F10x_StdPeriph_Lib_V3.5.0\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Lib_V3.5.0\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\Source\include;..\INC;..\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SRC
    ../SRC/: main.c HM10.c stm32f10x_it.c
    ./: Port_Mangger.c
  group STM32F10x_StdPeriph_Lib
    ../STM32F10x_StdPeriph_Lib_V3.5.0/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c
  group CMSIS
    ../STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Free_RTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
